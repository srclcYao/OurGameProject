# Keil uVision project Game1145.uvprojx, settings and files
target Target_1 (6160000::V6.16::ARMCLANG)
  device: GD32F450ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Game1145 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\CMSIS;..\User;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware\Inc;..\GameLogic\Inc;..\UI\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Hardware
    ../Hardware/Src/: Amplifier.c Font.c Joystick.c Key.c LED.c Screen.c Timer.c PWM.c Motor.c SPI.c Random.c Eeprom.c
    ../Hardware/Inc/: Motor.h Timer.h PWM.h SPI.h Random.h Eeprom.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Doc
    ../Doc/: readme.txt
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GameLogic
    ../GameLogic/Src/: Snake.c Food.c Score.c game.c
    ../GameLogic/Inc/: Snake.h Food.h Score.h game.h
  group UI
    ../UI/Src/: Image.c BasicDrawing.c
    ../UI/Inc/: Image.h BasicDrawing.h
